FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-DE1-SoC-disable-ECC-set-IFWIDTH-32.patch"

